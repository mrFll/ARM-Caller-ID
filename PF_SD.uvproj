# Keil uVision project PF_SD.uvproj, settings and files
target bihe.org (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: PF_SD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group SD Card
    ./Source/Flash/: File_Config.c Retarget.c SPI_LPC17xx.c FS_CM3.lib Serial.c
  group Main
    ./Source/: main.c
    ./Source/LPC17xx/: system_LPC17xx.c
    ./: startup_LPC17xx.s
    ./Source/Web/: Web.c
    ./Source/library_Http/: HTTP_CGI.c
  group HTTP Files
    ./Source/Web/: index.htm ledcontroll.cgi send_data.cgx Web.inp xml_http.js pg_header.inc pg_footer.inc sd.cgi
  group Config
    ./Source/library_Http/: Net_Config.c Net_Debug.c
  group Ethernet
    ./Source/library_Http/: EMAC_LPC17xx.c TCP_CM3.lib TCPD_CM3.lib
